Commit message: .

File: pioneer3at/urdf/pioneer3at.urdf (robot description, URDF)
Before this commit: robot pioneer3at, 17 links, 16 joints
Links:
- link top_plate: mass 0.1 -> 50
